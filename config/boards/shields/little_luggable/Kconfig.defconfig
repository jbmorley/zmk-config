## config/boards/shields/little_luggable/Kconfig.defconfig
```kconfig
if SHIELD_MY_BOARD

config ZMK_BLE
	default y

config ZMK_KEYBOARD_NAME
    default "Little Luggable"

endif
```
